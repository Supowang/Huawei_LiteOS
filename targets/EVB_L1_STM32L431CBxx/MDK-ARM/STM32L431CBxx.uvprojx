# Keil uVision project STM32L431CBxx.uvprojx, settings and files
target EVB_L1_STM32L431CBxx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L431CBTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: EVB_L1_STM32L431CBxx +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L431xx,WITH_AT_SOCKET,USE_ESP8266
  c include: ../Inc;../../../Drivers/stm32/STM32L4xx_HAL_Driver/Inc;../../../Drivers/stm32/STM32L4xx_HAL_Driver/Inc/Legacy;../../../Drivers/stm32/CMSIS/Device/ST/STM32L4xx/Include;../../../Drivers/stm32/CMSIS/Include;..\..\..\kernel\base\include;..\..\..\kernel\extended\include;..\..\..\kernel\include;..\..\..\include;..\..\..\osdepends\liteos;..\..\..\arch\arm\arm-m\include;..\OS_CONFIG;..\Hardware\KEY;..\Hardware\LED;..\Hardware\OLED;..\..\..\sensor_modules\DHT11;..\..\..\sensor_modules\BH1750;..\..\..\sensor_modules\MQ2;..\..\..\sensor_modules\esp8266;..\..\..\components\connectivity\mqtt\src;..\..\..\components\connectivity\mqtt\mqtt_adapter;..\..\..\components\net\at_socket
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32l431xx.s
  group Application/User
    ../Src/: main.c adc.c gpio.c usart.c stm32l4xx_it.c stm32l4xx_hal_msp.c dwt.c sys_init.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../Drivers/stm32/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Hardware
    ../Hardware/OLED/: oled.c
    ../Hardware/KEY/: key.c
    ../Hardware/LED/: led.c
  group liteos/cmsis
    ../../../osdepends/liteos/cmsis/: cmsis_liteos.c
  group liteos/arch
    ../../../arch/arm/arm-m/cortex-m4/keil/: los_dispatch_keil.S
    ../../../arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
  group liteos/kernel
    ../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../../../kernel/base/mem/common/: los_memcheck.c los_memstat.c los_slab.c los_slabmem.c
    ../../../kernel/base/mem/membox/: los_membox.c
    ../../../kernel/base/misc/: los_misc.c
    ../../../kernel/base/om/: los_err.c
    ../../../kernel/extended/tickless/: los_tickless.c
    ../../../kernel/: los_init.c
  group sensor_modules
    ../../../sensor_modules/DHT11/: dht11.c
    ../../../sensor_modules/BH1750/: bh1750.c
    ../../../sensor_modules/MQ2/: mq2.c
    ../../../sensor_modules/esp8266/: esp8266.c
  group at_socket
    ../../../components/net/at_socket/: at_api_interface.c at_hal_init.c at_socket.c at_uart.c
  group mqtt
    ../../../components/connectivity/mqtt/src/: MQTTConnectClient.c MQTTConnectServer.c MQTTDeserializePublish.c MQTTFormat.c MQTTPacket.c MQTTSerializePublish.c MQTTSubscribeClient.c MQTTSubscribeServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c
    ../../../components/connectivity/mqtt/mqtt_adapter/: mqtt_example.c transport.c
software components: CMSIS:CORE 4.3.0
