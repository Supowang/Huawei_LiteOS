# Keil uVision project STM32L496VGTx.uvprojx, settings and files
target EVB_H1_STM32L496VGTx (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L496VGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: EVB_H1_STM32L496VGTx +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L496xx
  c include: ../Inc;../../../Drivers/stm32/STM32L4xx_HAL_Driver/Inc;../../../Drivers/stm32/STM32L4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FatFs/src;../../../Drivers/stm32/CMSIS/Device/ST/STM32L4xx/Include;../../../Drivers/stm32//CMSIS/Include;..\..\..\include;..\..\..\kernel\base\include;..\..\..\kernel\extended\include;..\..\..\kernel\include;..\..\..\arch\arm\arm-m\include;..\OS_CONFIG;..\Hardware\LCD;..\..\..\sensor_modules\DHT11
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32l496xx.s
  group Application/User
    ../Src/: main.c gpio.c adc.c dcmi.c dma.c bsp_driver_sd.c sd_diskio.c fatfs.c fatfs_platform.c i2c.c usart.c rng.c sdmmc.c spi.c stm32l4xx_it.c stm32l4xx_hal_msp.c sys_init.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../Drivers/stm32/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_dcmi.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_ll_sdmmc.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group liteos/cmsis
    ../../../osdepends/liteos/cmsis/: cmsis_liteos.c
  group liteos/arch
    ../../../arch/arm/arm-m/cortex-m4/keil/: los_dispatch_keil.S
    ../../../arch/arm/arm-m/src/: los_hw.c los_hw_tick.c los_hwi.c
  group liteos/kernel
    ../../../kernel/base/core/: los_priqueue.c los_swtmr.c los_sys.c los_task.c los_tick.c los_timeslice.c
    ../../../kernel/base/ipc/: los_event.c los_mux.c los_queue.c los_sem.c
    ../../../kernel/base/mem/bestfit_little/: los_heap.c los_memory.c
    ../../../kernel/base/mem/common/: los_memcheck.c los_memstat.c los_slab.c los_slabmem.c
    ../../../kernel/base/mem/membox/: los_membox.c
    ../../../kernel/base/misc/: los_misc.c
    ../../../kernel/base/om/: los_err.c
    ../../../kernel/extended/tickless/: los_tickless.c
    ../../../kernel/: los_init.c
  group HardWare
    ../Hardware/LCD/: GUI.c Lcd_Driver.c QDTFT_demo.c
  group sensor_modules
    ../../../sensor_modules/DHT11/: dht11.c
software components: CMSIS:CORE 4.3.0
